# Keil uVision project ts_scanner.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ts_scanner +hex
  c flags: Optim=1
  c define: NRF51 BOARD_PCA10003 SETUPA DEBUG_NRF
  c misc: --c99
  c include: ..\Include;..\Include\arm;..\Include\sdk;..\Include\sdk\boards;..\..\..\nrf51822\Include;..\..\..\nrf51822\Include\app_common;..\..\..\nrf51822\Include\ble;..\..\..\nrf51822\Include\ble\ble_services;..\..\..\SD110\s110_nrf51822_7.0.0-4.prealpha_API\include
  memory RVCT4: ROM 0x16000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group app
    ../: main.c radio.c channel_resolver.c ll_scan.c nrf_adv_conn.c nrf_report_disp.c nrf_report_fifo.c nrf_scan.c
  group core
    ../Include/sdk/core/: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../nrf51822/Source/simple_uart/: simple_uart.c
    ../../../nrf51822/Source/ble/: ble_advdata.c
