# Keil uVision project nrf_observer.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ts_scanner +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 BOARD_PCA10003 SETUPA DEBUG_NRF
  c misc: --c99
  c include: ..\Include;..\..\Include;..\..\btle_hci\Include;..\..\btle_hci\fifo\Include;..\..\btle_hci\scanner\Include;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s110
  memory RVCT4: ROM 0x16000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group app
    ../: main.c nrf_adv_conn.c
  group core
    ../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../../Source/ble/: ble_advdata.c
  group btle_hci
    ../../btle_hci/fifo/: nrf_report_disp.c nrf_report_fifo.c
    ../../btle_hci/scanner/: channel_resolver.c ll_scan.c nrf_scan.c radio.c
