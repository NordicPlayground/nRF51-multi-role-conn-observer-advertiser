# Keil uVision project nrf_advertiser.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_beacon +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 BOARD_PCA10001 SETUPA
  c misc: --c99
  c include: ..\Include;..\Include\arm;..\Include\sdk;..\Include\sdk\boards;..\..\..\..\s110\s110_nrf51822_7.0.0_API\include;..\..\..\..\nrf51822\Include\app_common;..\..\..\..\nrf51422\Include\ble;..\..\..\..\nrf51422\Include\ble\ble_services;..\..\..\..\nrf51822\Include\s110
  memory RVCT4: ROM 0x16000 size 0x2c000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group app
    ../: main.c sd-jam.c ts_rng.c ts_whitelist.c ts_advertiser.c evt_fifo.c ts_evt_dispatcher.c ts_hal.c ts_controller.c
  group core
    ../../../../nrf51422/Source/templates/: system_nrf51.c
    ../../../../nrf51422/Source/templates/arm/: arm_startup_nrf51.s
  group lib
    ../../../../nrf51422/Source/ble/: ble_advdata.c
    ../../../../nrf51422/Source/simple_uart/: simple_uart.c
